# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,ARM_MATH_CM4,__CC_ARM,USE_MY_ASSERT,SWERVE_CHASSIS
  c misc: --cpp11
  c include: ../Core/Inc;       ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;       ../Drivers/STM32F4xx_HAL_Driver/Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;       ../Middlewares/Third_Party/FreeRTOS/Source/include;       ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;       ../Drivers/CMSIS/Include;       ..\USP\Application;       ..\USP\Drivers;       ..\USP\Middlewares\UpperMonitor;       ..\USP\Middlewares\Systemview;       ..\USP\Middlewares\Robot_Template;       ..\USP;       ..\SRML;       ..\Drivers\CMSIS\DSP\Include;       ..\SRML\Middlewares\Algorithm;       ..\SRML\Drivers\Devices;       ..\USP\Middlewares\Module;       ..\USP\Middlewares\Task;       ..\SRML\Middlewares\Module;       ..\SRML\Drivers\Components
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User/System
    ../USP/Application/: System_Config.cpp System_DataPool.cpp Service_Devices.cpp Service_Debug.cpp Service_Communication.cpp Service_SwerveChassis.cpp
    ../SRML/Middlewares/Utility/: com_manager.h dev_manager.h
    ../USP/: srml_config.h
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Middlewares/Robot_Template
    ../SRML/Middlewares/Module/: chassis.cpp power_ctrl.cpp
  group Middlewares/Algorithm
    ../SRML/Middlewares/Algorithm/: PID.cpp filters.cpp
  group Middlewares/Protocol
    ../SRML/Middlewares/Protocol/: SerialLineIP.cpp unified_frame.h
  group Middlewares/Utility
    ../SRML/Middlewares/Utility/: myAssert.h linux_list.h
  group Middlewares/Task
    ../USP/Middlewares/Task/: move_task.cpp UI_Task.cpp
  group Middlewares/Module
    ../USP/Middlewares/Module/: Hero_chassis.cpp Hero_config.cpp source_manage.cpp board_com.cpp
  group Middlewares/SystemView
    ../USP/Middlewares/Systemview/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_FreeRTOS.c SEGGER_SYSVIEW_Config_FreeRTOS.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/Devices
    ../SRML/Drivers/Devices/: motor.h motor_AK80.h referee.cpp
  group Drivers/Components
    ../SRML/Drivers/Components/: drv_can.c drv_timer.c drv_uart.c drv_i2c.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
